# Keil uVision project efr32_t1.uvprojx, settings and files
target whetstone (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EFR32MG1P132F256GM48 Silicon Labs
  pack: SiliconLabs.EFR32MG1P_DFP.5.4.1
  cpu: IRAM(0x20000000,0x00007C00) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: efr32_t1
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EFR32MG1P132F256
  c include: D:\SiliconLabs\SimplicityStudio\v4\developer\sdks\exx32\v5.0.0.0\platform\emlib\inc;D:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\hardware\kit\EFR32MG1_BRD4160A\config;E:\efr32_prj
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7c00
  group app
    ./: main.c
  group BSP
    ./: i2cspm.c board.c util.c retargetio.c retargetserial.c
  group emlib
    D:/SiliconLabs/SimplicityStudio/v4/developer/sdks/exx32/v5.0.0.0/platform/emlib/src/: em_cmu.c em_core.c em_emu.c em_gpio.c em_msc.c em_system.c em_timer.c em_usart.c em_i2c.c
  group doc
    ./: README.md
software components: CMSIS:CORE 5.1.1, Device:Startup 5.4.0
